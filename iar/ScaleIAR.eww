<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchBuildItem>Debug</batchBuildItem>
  </batchBuild>
  <project>
    <path>Scale/Scale.ewp</path>
  </project>
</workspace>

