# IAR project Scale.ewp, settings and files
configuration Debug (MSP430)
  General.OGChipSelectEditMenu: MSP430G2553
  General.GenDeviceSelectMenu: MSP430G2553
  ICC.CCIncludePath2: ../../src
  ICC.CCOptLevel: size
  ILINK.IlinkOutputFile: ../../build/iar/scale.elf
  group Source
    ../../src/: main.c i2c.c lcd_i2c.c hx711.c
  group Headers
    ../../src/: i2c.h lcd_i2c.h hx711.h
